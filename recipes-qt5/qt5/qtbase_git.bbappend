PACKAGECONFIG_append = "gles2 icu accessibility fontconfig dbus libinput "

OE_QMAKE_PATH_QT_FONTS = "${datadir}/fonts"
