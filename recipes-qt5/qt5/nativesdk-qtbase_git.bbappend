fakeroot do_generate_qt_environment_file_append() {
    chmod 755 ${D}${SDKPATHNATIVE}/environment-setup.d
}
