FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://setxkbmap.patch \
	    file://path_env.patch"

