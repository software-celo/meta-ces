FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-pcmanfm-set-usb-autorun-disable.patch \
            file://0002-pcmanfm-set-view-mode-detailed-list.patch \
           "
