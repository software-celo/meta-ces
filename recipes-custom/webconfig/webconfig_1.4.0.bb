require webconfig.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=1bcb54d6f4877c88b3a20f836d45f56c"

INC_PR = "r0"
SRCREV = "a314f102a2046eca2a1fc35373a3d2b32beebf7f"
