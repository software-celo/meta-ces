# Copyright (c) Steffen Kothe <skothe@christ-es.de> Christ Electronic Systems GmbH

require webconfig.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e65f866ca692a5385dd4ebea623fa3fa"

INC_PR = "r0"
SRCREV = "54fb8da3f3854ab7561967ffc7796a7d1fe677c6"
