FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-libfm-disable-trash.patch \
            file://0002-libfm-set-default-terminal.patch \
            file://0003-libfm-set-icon-size-for-compact-view.patch \
           "
