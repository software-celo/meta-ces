FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-add-qt-based-browsers.patch \
    file://0002-remove-exo-browser-and-mail.patch \
"
