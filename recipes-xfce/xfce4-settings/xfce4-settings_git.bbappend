DESCRIPTION = "Set double click time and distance"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-xsettings.xml-Set-double-click-time-and-distance.patch \
"

