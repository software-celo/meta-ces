inherit setuptools3
require python-cairosvg.inc
