RDEPENDS_${PN}_append = " \
    ${PYTHON_PN}-asyncio \
    ${PYTHON_PN}-json \
    ${PYTHON_PN}-multiprocessing \
    ${PYTHON_PN}-netserver \
"
