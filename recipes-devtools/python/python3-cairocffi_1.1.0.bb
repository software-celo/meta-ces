inherit setuptools3
require python-cairocffi.inc
