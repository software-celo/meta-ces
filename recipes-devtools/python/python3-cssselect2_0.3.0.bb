inherit setuptools3
require python-cssselect2.inc
