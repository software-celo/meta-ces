inherit setuptools3
require python-defusedxml.inc
