inherit setuptools3
require python-tinycss2.inc
