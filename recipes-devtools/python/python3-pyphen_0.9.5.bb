inherit setuptools3
require python-pyphen.inc
