inherit setuptools3
require python-weasyprint.inc
