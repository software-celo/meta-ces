FILESEXTRAPATHS_prepend := "${THISDIR}/udev-extraconf:"
